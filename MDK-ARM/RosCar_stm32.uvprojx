# Keil uVision project RosCar_stm32.uvprojx, settings and files
target RosCar (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Core;..\Hal\inc;..\Driver\auto_charge;..\Driver\data_commun;..\Driver\encoder_data;..\Driver\imu_data;..\Driver\init_function;..\Driver\moto_control;..\Driver\power_manage;..\Driver\golbal_variable;..\Driver\odometry;..\Driver\includes
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_md.s
  group Hal
    ../Hal/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c
  group Driver
    ../Driver/auto_charge/: auto_charge.c
    ../Driver/data_commun/: data_commun.c
    ../Driver/encoder_data/: encoder_data.c
    ../Driver/imu_data/: imu_data.c
    ../Driver/init_function/: init_function.c
    ../Driver/moto_control/: moto_control.c
    ../Driver/power_manage/: power_manage.c
    ../Driver/golbal_variable/: golbal_variable.c
    ../Driver/odometry/: odometry.c
